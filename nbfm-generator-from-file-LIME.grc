options:
  parameters:
    author: Jacob Miller
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: FM Radio Transmitter
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: tone_freq
  id: variable_qtgui_range
  parameters:
    label: Tone Frequency
    orient: Qt.Horizontal
    start: 100e6
    step: '1000'
    stop: 3500e6
    value: 1000e6
  states: {}
- name: tone_freq_offset
  id: variable_qtgui_range
  parameters:
    label: Offset Frequency
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: samp_rate/4
    value: '200000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: 1e3
    rate: '1e-4'
    reference: '0.6'
    type: complex
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 10e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/J.S.Bach-Partita-E-major.wav
    repeat: 'True'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch1: 10e6
    channel_mode: '1'
    digital_bandw_ch0: 2e6
    digital_bandw_ch1: '0'
    gain_dB_ch0: '60'
    gain_dB_ch1: '30'
    nco_freq_ch0: tone_freq_offset
    oversample: '0'
    pa_path_ch0: '1'
    pa_path_ch1: '1'
    rf_freq: tone_freq
    samp_rate: samp_rate
    serial: xxxxxxxxxxxxxxxxxx
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: firdes.WIN_HANN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2.0e6
    fc: 2.0e6
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,1,2
    name: NBFM Signal
    showports: 'True'
    type: complex
    units: dBm
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_agc_xx_0, '0', low_pass_filter_0, '0']
- [analog_nbfm_tx_0, '0', analog_agc_xx_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [low_pass_filter_0, '0', limesdr_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
