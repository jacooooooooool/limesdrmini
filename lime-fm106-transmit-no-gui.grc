options:
  parameters:
    author: Lime
    category: Custom
    generate_options: no_gui
    id: send_info4_77
    output_language: python
    run_options: run
    title: FM transmitter
  states: {}

blocks:
- name: analog_nbfm_tx_0_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 2e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /Music/komunikat.wav
    repeat: 'False'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    analog_bandw_ch1: '0'
    calibr_bandw_ch0: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '60'
    gain_dB_ch1: '60'
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: 106e6
    samp_rate: 1e6
    serial: xxxxxxxxxxxx
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 446.09375e6
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: 2.5e6
    fc: 89e6
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_base_xxx_0
  id: rational_resampler_base_xxx
  parameters:
    decim: '1'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    fbw: ''
    interp: '25'
    taps: ''
    type: ccc
  states: {}
- name: wxgui_fftsink2_0
  id: wxgui_fftsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: 446.09375e6
    fft_rate: '15'
    fft_size: '1024'
    freqvar: None
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: 2e6
    title: Transmitting data
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {state: disabled}

connections:
- [analog_nbfm_tx_0_0, '0', rational_resampler_base_xxx_0, '0']
- [analog_nbfm_tx_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0_0, '0', analog_nbfm_tx_0_0, '0']
- [rational_resampler_base_xxx_0, '0', limesdr_sink_0, '0']
- [rational_resampler_base_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_base_xxx_0, '0', qtgui_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', limesdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', wxgui_fftsink2_0, '0']

metadata:
  file_format: 1
