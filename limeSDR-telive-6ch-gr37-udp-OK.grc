options:
  parameters:
    author: Jacek Lipkowski SQ5BPF
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: SQ5BPF Tetra live receiver 6ch UDP demo (gnuradio 37 version)
  states: {}

blocks:
- name: first_decim
  id: variable
  parameters:
    value: '32'
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: samp_rate/first_decim
  states: {}
- name: options_low_pass
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: out_sample_rate
  id: variable
  parameters:
    value: '36000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: udp_dest_addr
  id: variable
  parameters:
    value: '"127.0.0.1"'
  states: {}
- name: udp_first_port
  id: variable
  parameters:
    value: '42001'
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: udp_dest_addr
    port: udp_first_port+0
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: udp_dest_addr
    port: udp_first_port+1
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_1
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: udp_dest_addr
    port: udp_first_port+2
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_2
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: udp_dest_addr
    port: udp_first_port+3
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_3
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: udp_dest_addr
    port: udp_first_port+5
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_4
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: udp_dest_addr
    port: udp_first_port+4
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: fractional_resampler_xx_0
  id: fractional_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: fractional_resampler_xx_0_0
  id: fractional_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: fractional_resampler_xx_0_1
  id: fractional_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: fractional_resampler_xx_0_2
  id: fractional_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: fractional_resampler_xx_0_3
  id: fractional_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: fractional_resampler_xx_0_4
  id: fractional_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: freq
  id: variable_text_box
  parameters:
    converver: float_converter
    formatter: None
    grid_pos: 1,0,1,1
    label: Center Freq
    value: 426.e6
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset1+xlate_offset_fine1
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset2+xlate_offset_fine2
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset3+xlate_offset_fine3
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset4+xlate_offset_fine4
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset5+xlate_offset_fine5
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset6+xlate_offset_fine6
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: frx1
  id: variable_static_text
  parameters:
    converver: float_converter
    formatter: None
    grid_pos: 2,0,1,1
    label: RX1
    value: freq+xlate_offset1+xlate_offset_fine1
  states: {}
- name: frx2
  id: variable_static_text
  parameters:
    converver: float_converter
    formatter: None
    grid_pos: 3,0,1,1
    label: RX1
    value: freq+xlate_offset2+xlate_offset_fine2
  states: {}
- name: frx3
  id: variable_static_text
  parameters:
    converver: float_converter
    formatter: None
    grid_pos: 4,0,1,1
    label: RX3
    value: freq+xlate_offset3+xlate_offset_fine3
  states: {}
- name: frx4
  id: variable_static_text
  parameters:
    converver: float_converter
    formatter: None
    grid_pos: 5,0,1,1
    label: RX4
    value: freq+xlate_offset4+xlate_offset_fine4
  states: {}
- name: frx5
  id: variable_static_text
  parameters:
    converver: float_converter
    formatter: None
    grid_pos: 6,0,1,1
    label: RX5
    value: freq+xlate_offset5+xlate_offset_fine5
  states: {}
- name: frx6
  id: variable_static_text
  parameters:
    converver: float_converter
    formatter: None
    grid_pos: 7,0,1,1
    label: RX6
    value: freq+xlate_offset6+xlate_offset_fine6
  states: {}
- name: notebook1
  id: notebook
  parameters:
    grid_pos: 0,0,1,5
    labels: '[''F1'', ''F2'', ''F3'',''F4'',''F5'',''F6'']'
    style: wx.NB_TOP
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    ant0: LNAW
    args: soapy=0,driver=lime
    bb_gain0: sdr_bbgain
    bw0: samp_rate
    freq0: freq
    gain0: sdr_gain
    gain_mode0: 'True'
    if_gain0: sdr_ifgain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: ppm_corr
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 1,1,1,1
    label: ppm
    max: '100'
    min: '-100'
    num_steps: '200'
    style: wx.SL_HORIZONTAL
    value: '56'
  states: {}
- name: sdr_bbgain
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 1,5,1,1
    label: ''
    max: '30'
    min: '0'
    num_steps: '30'
    style: wx.SL_HORIZONTAL
    value: '20'
  states: {}
- name: sdr_gain
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 1,2,1,1
    label: ''
    max: '60'
    min: '0'
    num_steps: '60'
    style: wx.SL_HORIZONTAL
    value: '40'
  states: {}
- name: sdr_ifgain
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 1,3,1,1
    label: ''
    max: '30'
    min: '0'
    num_steps: '30'
    style: wx.SL_HORIZONTAL
    value: '20'
  states: {}
- name: wxgui_fftsink2_0_0_0
  id: wxgui_fftsink2
  parameters:
    average: 'True'
    avg_alpha: '0.1'
    baseband_freq: '0'
    fft_rate: '32'
    fft_size: '256'
    freqvar: None
    notebook: notebook1,0
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: if_samp_rate
    title: Channel 1 FFT
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {}
- name: wxgui_fftsink2_0_0_0_0
  id: wxgui_fftsink2
  parameters:
    average: 'True'
    avg_alpha: '0.1'
    baseband_freq: '0'
    fft_rate: '32'
    fft_size: '256'
    freqvar: None
    notebook: notebook1,1
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: if_samp_rate
    title: Channel 2 FFT
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {}
- name: wxgui_fftsink2_0_0_0_0_0
  id: wxgui_fftsink2
  parameters:
    average: 'True'
    avg_alpha: '0.1'
    baseband_freq: '0'
    fft_rate: '32'
    fft_size: '256'
    freqvar: None
    notebook: notebook1,2
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: if_samp_rate
    title: Channel 3 FFT
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {}
- name: wxgui_fftsink2_0_0_0_0_0_0
  id: wxgui_fftsink2
  parameters:
    average: 'True'
    avg_alpha: '0.1'
    baseband_freq: '0'
    fft_rate: '32'
    fft_size: '256'
    freqvar: None
    notebook: notebook1,3
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: if_samp_rate
    title: Channel 4 FFT
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {}
- name: wxgui_fftsink2_0_0_0_0_0_0_0
  id: wxgui_fftsink2
  parameters:
    average: 'True'
    avg_alpha: '0.1'
    baseband_freq: '0'
    fft_rate: '32'
    fft_size: '256'
    freqvar: None
    notebook: notebook1,4
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: if_samp_rate
    title: Channel 5 FFT
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {}
- name: wxgui_fftsink2_0_0_0_0_0_0_0_0
  id: wxgui_fftsink2
  parameters:
    average: 'True'
    avg_alpha: '0.1'
    baseband_freq: '0'
    fft_rate: '32'
    fft_size: '256'
    freqvar: None
    notebook: notebook1,5
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: if_samp_rate
    title: Channel 6 FFT
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {}
- name: xlate_offset1
  id: variable_text_box
  parameters:
    converver: float_converter
    formatter: None
    grid_pos: 2,1,1,1
    label: Offset1
    value: 625e3
  states: {}
- name: xlate_offset2
  id: variable_text_box
  parameters:
    converver: float_converter
    formatter: None
    grid_pos: 3,1,1,1
    label: Offset2
    value: '-250000'
  states: {}
- name: xlate_offset3
  id: variable_text_box
  parameters:
    converver: float_converter
    formatter: None
    grid_pos: 4,1,1,1
    label: Offset3
    value: '-225000'
  states: {}
- name: xlate_offset4
  id: variable_text_box
  parameters:
    converver: eval_converter
    formatter: None
    grid_pos: 5,1,1,1
    label: Offset4
    value: '-75000'
  states: {}
- name: xlate_offset5
  id: variable_text_box
  parameters:
    converver: float_converter
    formatter: None
    grid_pos: 6,1,1,1
    label: Offset5
    value: '-100000'
  states: {}
- name: xlate_offset6
  id: variable_text_box
  parameters:
    converver: float_converter
    formatter: None
    grid_pos: 7,1,1,1
    label: Offset6
    value: '100000'
  states: {}
- name: xlate_offset_fine1
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 2,2,1,3
    label: Fine1
    max: '5000'
    min: '-5000'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '0'
  states: {}
- name: xlate_offset_fine2
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 3,2,1,3
    label: Fine2
    max: '5000'
    min: '-5000'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '0'
  states: {}
- name: xlate_offset_fine3
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 4,2,1,3
    label: Fine3
    max: '5000'
    min: '-5000'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '0'
  states: {}
- name: xlate_offset_fine4
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 5,2,1,3
    label: Fine4
    max: '5000'
    min: '-5000'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '0'
  states: {}
- name: xlate_offset_fine5
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 6,2,1,3
    label: Fine4
    max: '5000'
    min: '-5000'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '0'
  states: {}
- name: xlate_offset_fine6
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 7,2,1,3
    label: Fine4
    max: '5000'
    min: '-5000'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '0'
  states: {}

connections:
- [fractional_resampler_xx_0, '0', blocks_udp_sink_0, '0']
- [fractional_resampler_xx_0_0, '0', blocks_udp_sink_0_0, '0']
- [fractional_resampler_xx_0_1, '0', blocks_udp_sink_0_1, '0']
- [fractional_resampler_xx_0_2, '0', blocks_udp_sink_0_2, '0']
- [fractional_resampler_xx_0_3, '0', blocks_udp_sink_0_4, '0']
- [fractional_resampler_xx_0_4, '0', blocks_udp_sink_0_3, '0']
- [freq_xlating_fir_filter_xxx_0, '0', fractional_resampler_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', wxgui_fftsink2_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', fractional_resampler_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', wxgui_fftsink2_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', fractional_resampler_xx_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', wxgui_fftsink2_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', fractional_resampler_xx_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', wxgui_fftsink2_0_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0, '0', fractional_resampler_xx_0_3, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0, '0', wxgui_fftsink2_0_0_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0', fractional_resampler_xx_0_4, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0', wxgui_fftsink2_0_0_0_0_0_0_0_0, '0']
- [osmosdr_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_1, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [osmosdr_source_1, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [osmosdr_source_1, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [osmosdr_source_1, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0, '0']
- [osmosdr_source_1, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0']

metadata:
  file_format: 1
