options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: keyfob_rx
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1.0/10000
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: sps
    max_iter: '4000'
    scale: 1.0/sps
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: sps*(1+0.0)
    omega_relative_limit: '0.05'
    type: float
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"10101000"'
    tagname: packet_start
    threshold: '0'
    type: byte
  states: {}
- name: keyfob_manchester_decode_0
  id: keyfob_manchester_decode
  parameters: {}
  states: {}
- name: keyfob_parse_packet_0
  id: keyfob_parse_packet
  parameters: {}
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    ch_align: 'False'
    channel_mode: '0'
    oversample: '0'
    rf_freq: '433996000'
    samp_rate: 1e6
    serial: xxxxxxxxxxxxxxxxx
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    freq0: '433996000'
    gain0: '2'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: '1000000'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 3393.75*sps/1000000.026491
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: 3400 * sps
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: '3400'
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_sub_xx_0, '0']
- [blocks_divide_xx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_moving_average_xx_1, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_moving_average_xx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', keyfob_manchester_decode_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', keyfob_parse_packet_0, '0']
- [keyfob_manchester_decode_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [limesdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_moving_average_xx_1, '0']

metadata:
  file_format: 1
